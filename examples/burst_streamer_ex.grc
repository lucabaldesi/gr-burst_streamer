options:
  parameters:
    author: baldo
    generate_options: qt_gui
    id: burst_streamer_ex
    output_language: python
    title: Example burst streamer
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/2
    type: complex
  states: {}
- name: burst_streamer_burst_streamer_0
  id: burst_streamer_burst_streamer
  parameters:
    max_outputs: samp_rate*duration
    samples_per_second: samp_rate
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '32000'
    srate: samp_rate
    type: complex
    ymin: '0'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', burst_streamer_burst_streamer_0, '0']
- [burst_streamer_burst_streamer_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
